# Keil uVision project 魔鬼鱼.uvprojx, settings and files
target 魔鬼鱼 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Template +hex
  c flags: Optim=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM;..\Drivers;..\FATFS\exfuns;..\FATFS\src;..\FATFS\doc;..\Drivers\BEEP;..\Drivers\EXTI;..\Drivers\KEY;..\Drivers\LCD;..\Drivers\LED;..\Drivers\OV7670;..\Drivers\SDIO;..\Drivers\SPI;..\Drivers\TIMER;..\Drivers\W25QXX;..\Drivers\TPAD;..\MALLOC;..\PICTURE;..\TEXT;..\USMART
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: system.c
  group README
    ../: README.TXT
  group Driver
    ../Drivers/: motor.c duoji.c task.c ds18b20.c
    ../Drivers/BEEP/: beep.c
    ../Drivers/EXTI/: exti.c
    ../Drivers/KEY/: key.c
    ../Drivers/LCD/: lcd.c
    ../Drivers/LED/: led.c
    ../Drivers/OV7670/: ov7670.c sccb.c
    ../Drivers/SDIO/: sdio_sdcard.c
    ../Drivers/SPI/: spi.c
    ../Drivers/TIMER/: timer.c
    ../Drivers/TPAD/: tpad.c
    ../Drivers/W25QXX/: w25qxx.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group MALLOC
    ../MALLOC/: malloc.c
